Commit message: feat:调节头部控制方向

File: src/ros_robot_model/biped_s4/urdf/biped_s4.urdf (robot description, URDF)
Before this commit: robot biped_s4, 61 links, 60 joints
Joints:
- joint head_pitch: axis 0 1 0 -> 0 -1 0
- joint head_yaw: axis 0 0 -1 -> 0 0 1
